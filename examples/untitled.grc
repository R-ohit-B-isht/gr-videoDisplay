options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rohit/Videos/video/video-app-ffmpeg-opengl/video.mp4
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              with open('/home/rohit/Videos/trial/data.txt', 'a') as file:
                  file.write(np.array2string(input_items[0]))
              print(input_items[0])
             
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '1234'
    server: 'False'
    type: byte
  states: {}
- name: videoDisplay_video_display_0
  id: videoDisplay_video_display
  parameters:
    file: /home/rohit/Videos/trial/trial.mp4
    type: byte
    vlen: '1'
  states: {}

connections:
- [blocks_file_source_0, '0', epy_block_0, '0']
- [epy_block_0, '0', videoDisplay_video_display_0, '0']
- [network_tcp_source_0, '0', videoDisplay_video_display_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
